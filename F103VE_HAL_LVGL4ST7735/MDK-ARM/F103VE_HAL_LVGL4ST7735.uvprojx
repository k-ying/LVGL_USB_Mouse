# Keil uVision project F103VE_HAL_LVGL4ST7735.uvprojx, settings and files
target F103VE_HAL_LVGL4ST7735 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.2
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: F103VE_HAL_LVGL4ST7735 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;     ../Drivers/STM32F1xx_HAL_Driver/Inc;     ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;     ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;     ../Drivers/CMSIS/Include;     ..\Drivers\ST7735;     ..\GUI_lvgl;     ..\GUI_lvgl\lvgl;     ..\GUI_lvgl\lvgl_driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: main.c gpio.c dma.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/ST7735
    ../Drivers/ST7735/: fonts.c fonts.h st7735.c st7735.h testimg.h
  group GUI/lvgl_src
    ../GUI_lvgl/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../GUI_lvgl/lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../GUI_lvgl/lvgl/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../GUI_lvgl/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../GUI_lvgl/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../GUI_lvgl/lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ../GUI_lvgl/lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group GUI/lvgl_dvr
    ../GUI_lvgl/lvgl_driver/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
    ../GUI_lvgl/: lv_conf.h
    ../GUI_lvgl/lvgl/: lvgl.h
software components: CMSIS:CORE 4.3.0
